# Repository lpyha/Avio-BMS

## KiCad design Avio-BMS.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
TP1, TP2: TestPoint; PinHeader_1x01_P2.54mm_Vertical

Connections:
GND: H1.1, H2.1, H3.1, H4.1, TP1.1, TP2.1; also elsewhere on the board

Notes on the sheet:
USB-Output or MainBatteryOutput
3.3V2A
SubBattery
MainBattery or USBOutput
MainBattery
USB-PD 5V3A
7.4V2A

Parts:
C11, C12, C17, C18, C19: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13, C14, C15, C16: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D4, D5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
JP1: R_HYS; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
Q3, Q4: IRF7324; SOIC-8_3.9x4.9mm_P1.27mm
R16, R17, R18, R19, R20, R21, R22: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2: LTC4417CGN; SSOP-24_3.9x8.7mm_P0.635mm

Connections:
GND: C11.2, C12.2, C13.1, C14.1, C15.2, C16.1, C17.2, C18.2, C19.2, JP1.3 (B), R18.2, R21.2, R22.2, U2.8 (UV3), U2.9 (OV3), U2.13 (GND), U2.16 (G3), U2.17 (VS3), U2.22 (V3); also elsewhere on the board
unnamed: D4.2 (A), R23.1
unnamed: D5.2 (A), R24.1
unnamed: JP1.1 (A), R22.1
unnamed: JP1.2 (C), U2.3 (HYS)
unnamed: Q3.2 (G1), Q4.4 (G2), U2.20 (G1)
unnamed: C15.1, Q3.1 (S1), Q4.3 (S2), U2.21 (VS1)
unnamed: Q3.4 (G2), Q4.2 (G1), U2.18 (G2)
unnamed: C16.2, Q3.3 (S2), Q4.1 (S1), U2.19 (VS2)
OV1: R17.2, R18.1, U2.5 (OV1)
OV2: R20.2, R21.1, U2.7 (OV2)
UV1: R16.2, R17.1, U2.4 (UV1)
UV2: R19.2, R20.1, U2.6 (UV2)
V1: C11.1, C13.2, Q3.7 (D1), Q3.8 (D1), R16.1, U2.24 (V1); also elsewhere on the board
V2: C12.1, C14.2, Q4.7 (D1), Q4.8 (D1), R19.1, U2.23 (V2); also elsewhere on the board
VCC: C17.1, C18.1, C19.1, Q3.5 (D2), Q3.6 (D2), Q4.5 (D2), Q4.6 (D2), R23.2, R24.2, U2.15 (VOUT); also elsewhere on the board
~VALID1: D4.1 (K), U2.10 (~VALID1)
~VALID2: D5.1 (K), U2.11 (~VALID2)

Notes on the sheet:
Indicator
MainBat-V_{OUT}1,SubBat-V_{OUT}2->VCC

Parts:
C3, C5, C7: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C6: 100u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8, C10: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: OPT; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: indi-charge; LED_0603_1608Metric
J4, J5: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
L1: 3.3u; CDRH6D38NP-3R3NC
Q1, Q2: Si2333DDS-T1-GE3; SOT-23-3
R5: 40k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 8.2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 2.94k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R12, R13: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 499; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: OPT; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP4: BAT-FLOAT4.2V,0.5A; Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork
U1: LTC4088EDE-TRPBF; DFN-14_DE_LIT

Connections:
/Li-ionBatteryCharger,PowerPath/*CHRG: R14.2, U1.7 (*CHRG)
/Li-ionBatteryCharger,PowerPath/D1: J4.2, U1.14 (D1)
/Li-ionBatteryCharger,PowerPath/D2: J5.2, U1.4 (D2)
/Li-ionBatteryCharger,PowerPath/GATE: R13.1, U1.8 (GATE)
/Li-ionBatteryCharger,PowerPath/V_{IN}: C4.1, C6.1, J4.3, J5.3, Q1.3 (D), R8.1, U1.11 (VBUS)
GND: C4.2, C5.2, C6.2, C7.1, C8.2, C10.2, J4.1, J5.1, R5.2, R7.2, R11.2, R12.2, R15.2, U1.13 (D0), U1.15 (GND); also elsewhere on the board
Main-Bat: C7.2, C9.2, Q2.3 (D), TP4.1, U1.9 (BAT); also elsewhere on the board
NTC: R8.2, R9.1, R10.1, R12.1, U1.1 (NTC)
NTC1: R9.2; also elsewhere on the board
NTC2: R10.2; also elsewhere on the board
unnamed: C5.1, R6.2
unnamed: C9.1, R15.1
unnamed: D3.1 (K), R14.1
unnamed: C3.1, Q1.1 (G), R5.1
unnamed: Q2.1 (G), R13.2
unnamed: R6.1, R7.1, U1.2 (CLPROG)
unnamed: R11.1, U1.5 (C/X), U1.6 (PROG)
unnamed: L1.1, U1.12 (SW)
V1: C8.1, C10.1, D3.2 (A), L1.2, Q2.2 (S), U1.3 (LDO3V3), U1.10 (VOUTS); also elsewhere on the board
VBUS: C3.2, Q1.2 (S); also elsewhere on the board

Notes on the sheet:
バッテリーとバッテリーケースのサイズが合うことを要確認 保護回路入りLi-ionのサイズはメーカーによってバラバラ 1043Pは68.9
・Charging->ON ・I_{BAT}<C/X ->OFF ・NTCFault->35kHz 6.25%or93.75%(DUTY) ・BadBattery->35kHz 12.5%or87.5%(DUTY)
I_{BAT}=(V_{PROG}/R_{PROG})*1031 V_{PROG}の電圧で充電電流がわかる
USBソフト接続
CDRH6D38NP-3R3NC
発振防止
Li-ionバッテリーチャージャー 1cell/PowerPath
MainBattery-layerにつながる

Parts:
C20, C22, C29, C31, C33, C35: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C23, C30, C32, C34, C36: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C24, C25, C26, C28, C37: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27: 8.2n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C38: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C39: 43p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C40: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D6: LED; LED_0603_1608Metric
L2: 1.5u; L_Vishay_IHLP-1616
L3: 1u; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R25, R27, R28: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 115k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30: 28.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP5: 6V; Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork
TP6: 3.3V; Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork
U3: TPS63021DSJR; IC_TPS63021DSJR; PARTREV I
U4: TPS61088RHLR; IC_TPS61088RHLR; PARTREV 4219071/A 05/2017

Connections:
+3.3V: C30.1, C32.1, C34.1, C36.1, R29.2, TP6.1, U3.3 (FB), U3.4 (VOUT_4), U3.5 (VOUT_5); also elsewhere on the board
+6V: C28.1, C29.1, C31.1, C33.1, C35.1, R27.1, TP5.1, U4.14 (VOUT_16), U4.15 (VOUT_14), U4.16 (VOUT_15); also elsewhere on the board
/DCDC3.3V&7.4VOutput/COMP_{TPS61088}: C39.2, R30.1, U4.18 (COMP)
/DCDC3.3V&7.4VOutput/EN_{TPS61088}: C38.1, U4.1 (VCC_{TPS61088}), U4.2 (EN)
/DCDC3.3V&7.4VOutput/FB_{TPS61088}: R27.2, R28.1, U4.17 (FB)
/DCDC3.3V&7.4VOutput/SW_4567: C37.2, L2.2, R25.1, U4.4 (SW_7), U4.5 (SW_4), U4.6 (SW_5), U4.7 (SW_6)
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C39.1, C40.1, R26.2, R28.2, U3.2 (GND), U3.13 (PS/SYNC), U3.15 (PGND), U3.16, U3.17, U3.18, U3.19, U3.20, U3.21, U3.22, U3.23, U3.24, U3.25, U3.26, U3.27, U3.28, U3.29, U3.30, U4.13 (MODE), U4.20 (AGND), U4.21 (PGND), U4.22 (PGND__1), U4.23 (PGND__2), U4.24 (PGND__3), U4.25 (PGND__4), U4.26 (PGND__5), U4.27 (PGND__6), U4.28 (PGND__7), U4.29 (PGND__8); also elsewhere on the board
unnamed: C40.2, R30.2
unnamed: D6.2 (A), R29.1
unnamed: D6.1 (K), U3.14 (PG)
unnamed: C26.1, U3.1 (VINA), U3.12 (EN)
unnamed: L3.1, U3.8 (L1_8), U3.9 (L1_9)
unnamed: L3.2, U3.6 (L2_6), U3.7 (L2_7)
unnamed: C37.1, U4.8 (BOOT)
unnamed: R25.2, U4.3 (FSW)
unnamed: R26.1, U4.19 (ILIM)
unnamed: C27.1, U4.10 (SS)
VCC: C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, L2.1, U3.10 (VIN_10), U3.11 (VIN_11), U4.9 (VIN); also elsewhere on the board

Notes on the sheet:
11V->R27=976k, R28=120k 6V->R27=470k, R28=118k
PWMmodeで使用する
3.3V MCU/Sensor

Parts:
C1: 4700p; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: DF2S232CTC; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: indi-VBUS; LED_0603_1608Metric
J1: MainBattery; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J2: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
J3: SubBattery; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
R1: 10M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP3: VBUS; Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork

Connections:
GND: C1.2, C2.2, D1.2 (A), D2.1 (K), J1.1, J2.A1_B12 (GND), J2.B1_A12 (GND), J3.1, R1.1, R2.1, R3.2; also elsewhere on the board
Main-Bat: J1.3; also elsewhere on the board
NTC1: J1.2; also elsewhere on the board
NTC2: J3.2; also elsewhere on the board
unnamed: C1.1, J2.S1 (SHIELD), J2.S2 (SHIELD), J2.S3 (SHIELD), J2.S4 (SHIELD), R1.2
unnamed: D2.2 (A), R4.1
unnamed: J2.A5 (CC1), R2.2
unnamed: J2.B5 (CC2), R3.1
V2: J3.3; also elsewhere on the board
VBUS: C2.1, D1.1 (K), J2.A4_B9 (VBUS), J2.B4_A9 (VBUS), R4.2, TP3.1; also elsewhere on the board

Notes on the sheet:
USB-PD
USB-type-C

Parts:
J6, J8: +3.3V; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J7, J9: +6V; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical

Connections:
+3.3V: J6.2, J8.2; also elsewhere on the board
+6V: J7.2, J9.2; also elsewhere on the board
GND: J6.1, J7.1, J8.1, J9.1; also elsewhere on the board

Board: 2 copper layers, 80.0 x 80.0 mm, 107 parts (0 on the bottom side), 56 nets.

File Avio-BMS-BOM.csv:

"Reference","Value","Footprint","Qty","DNP"
"C1","4700p","Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder","1",""
"C2,C8,C10,C11,C12,C17,C18,C19,C20,C22,C29,C31,C33,C35","10u","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","14",""
"C3,C5,C7,C13,C14,C15,C16,C24,C25,C26,C28,C37","0.1u","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","12",""
"C4,C6","100u","Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder","2",""
"C9,R15","OPT","-- ミックスされた値 --","2",""
"C21,C23,C30,C32,C34,C36","22u","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","6",""
"C27","8.2n","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"C38,L3","1u","-- ミックスされた値 --","2",""
"C39","43p","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"C40","1n","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"D1","DF2S232CTC","Diode_SMD:D_0603_1608Metric_Pad1.05x0.95mm_HandSolder","1",""
"D2","indi-VBUS","LED_SMD:LED_0603_1608Metric","1",""
"D3","indi-charge","LED_SMD:LED_0603_1608Metric","1",""
"D4,D5,D6","LED","-- ミックスされた値 --","3",""
"J1","MainBattery","Connector_JST:JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical","1",""
"J2","5077CR-16SMC2-BK-TR","5077CR-16SMC2-BK-TR:NELTRON_5077CR-16SMC2-BK-TR","1",""
"J3","SubBattery","Connector_JST:JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical","1",""
"J4,J5","Conn_01x03_Pin","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","2",""
"J6,J8","+3.3V","Connector_JST:JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical","2",""
"J7,J9","+6V","Connector_JST:JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical","2",""
"JP1","R_HYS","Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels","1",""
"L1","3.3u","CDRH6D38NP-3R3NC:CDRH6D38NP-3R3NC","1",""
"L2","1.5u","Inductor_SMD:L_Vishay_IHLP-1616","1",""
"Q1,Q2","Si2333DDS-T1-GE3","Package_TO_SOT_SMD:SOT-23-3","2",""
"Q3,Q4","IRF7324","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","2",""
"R1","10M","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R2,R3","5.1k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","2",""
"R4,R14,R16,R17,R18,R19,R20,R21,R22,R25,R27,R28","R","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","12",""
"R5","40k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R6","8.2","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R7","2.94k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R8","100k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R9,R10,R12,R13","0","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","4",""
"R11","499","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R23","2k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R24","1k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R26","115k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R29","1M","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"R30","28.7k","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","1",""
"TP1,TP2","TestPoint","Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical","2",""
"TP3","VBUS","Connector_Pin:Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork","1",""
"TP4","BAT-FLOAT4.2V,0.5A","Connector_Pin:Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork","1",""
"TP5","6V","Connector_Pin:Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork","1",""
"TP6","3.3V","Connector_Pin:Pin_D1.1mm_L8.5mm_W2.5mm_FlatFork","1",""
"U1","LTC4088EDE-TRPBF","footprints:DFN-14_DE_LIT","1",""
"U2","LTC4417CGN","Package_SO:SSOP-24_3.9x8.7mm_P0.635mm","1",""
"U3","TPS63021DSJR","TPS63021DSJR:IC_TPS63021DSJR","1",""
"U4","TPS61088RHLR","TPS61088RHLR:IC_TPS61088RHLR","1",""

## Commit log

2024-10-08 Update KiCad project files
2024-10-09 update pcb layoput
2024-10-09 LTC4088の修正必須
2024-10-09 Remove unnecessary KiCad project files
2024-10-10 add block image
2024-10-14 update pcb
2024-10-15 update pcb ltc4088kitsui
2024-10-16 ltc4417
2024-10-16 ltc4417 update
2024-10-29 update pcb sch
2024-10-29 ad datasheet
2024-11-01 remove autosave and lock files; update component values and footprints; add new drill and Gerber files; create BOM
2024-11-11 update sch
2024-11-15 値の更新とテキストボックスの修正; LTC4088およびLTC4417の新しいテキスト追加
